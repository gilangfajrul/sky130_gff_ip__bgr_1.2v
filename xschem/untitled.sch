** sch_path: xschem/untitled.sch
**.subckt untitled
R1 net2 vbgtc 155k m=1
R3 vbgtc vbgsc 22k m=1
R4 vbgsc net1 315k m=1
**.ends
.end
