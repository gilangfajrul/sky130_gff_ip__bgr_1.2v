v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {nmos_startup.sym} 240 -130 0 0 {name=x25}
C {pmos_startup.sym} 240 -220 0 0 {name=x26}
C {resistorstart.sym} 240 -50 0 0 {name=x27}
C {devices/lab_pin.sym} 390 -250 2 0 {name=p72 sig_type=std_logic lab=vdde}
C {devices/lab_pin.sym} 390 -30 2 0 {name=p73 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 390 -110 2 0 {name=p74 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 390 -190 2 0 {name=p140 sig_type=std_logic lab=net20}
C {devices/lab_pin.sym} 390 -150 2 0 {name=p141 sig_type=std_logic lab=net20}
C {devices/lab_pin.sym} 390 -210 2 0 {name=p142 sig_type=std_logic lab=net21}
C {devices/lab_pin.sym} 390 -70 2 0 {name=p143 sig_type=std_logic lab=net21}
C {devices/lab_pin.sym} 390 -50 2 0 {name=p144 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 390 -230 2 0 {name=p145 sig_type=std_logic lab=out}
C {devices/lab_pin.sym} 390 -130 2 0 {name=p146 sig_type=std_logic lab=out}
C {iopin.sym} 610 -240 0 0 {name=p1 lab=vdde}
C {iopin.sym} 610 -220 0 0 {name=p2 lab=avss}
C {opin.sym} 610 -200 0 0 {name=p3 lab=out}
