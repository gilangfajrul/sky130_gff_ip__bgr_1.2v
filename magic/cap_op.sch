v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 55 120 90 120 {
lab=B}
C {sky130_fd_pr/cap_mim_m3_1.sym} 120 120 1 0 {name=C1 model=cap_mim_m3_1 W=17 L=17 MF=4 spiceprefix=X}
C {devices/iopin.sym} 150 120 0 0 {name=p9 lab=A}
C {devices/iopin.sym} 55 120 2 0 {name=p1 lab=B}
